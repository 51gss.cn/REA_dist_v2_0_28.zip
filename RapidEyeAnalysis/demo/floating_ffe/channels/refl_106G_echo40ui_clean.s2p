! Created with skrf 1.10.0 (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (through path):
!   3826 points, 10 MHz to 95.62 GHz, reference 50 ohm
!   highest |S21| = -0.06 dB at 10 MHz (marker M1); lowest = -10.7 dB at 95.62 GHz (marker M2)
!   group delay of S21, straight-line fit = 666 ps
!   lowest |S11| = - dB at 10 MHz (marker M3), VSWR 1.00, Z = 50 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from - to - dB; largest |S21 - S12| = 2.5e-16
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! magnitudes (dB):
! f  S21  S12
! 10 MHz  -0.1  -0.1
! 235 MHz  -0.3  -0.3
! 784.9 MHz  -0.6  -0.6
! 1.16 GHz  -0.7  -0.7
! 1.61 GHz  -0.8  -0.8
! 2.21 GHz  -1.0  -1.0
! 2.935 GHz  -1.1  -1.1
! 4.66 GHz  -1.5  -1.5
! 6.859 GHz  -1.9  -1.9
! 9.459 GHz  -2.3  -2.3
! 12.51 GHz  -2.7  -2.7
! 15.96 GHz  -3.1  -3.1
! 19.43 GHz  -3.6  -3.6
! 23.23 GHz  -4.0  -4.0
! 31.88 GHz  -4.9  -4.9
! 39.46 GHz  -5.7  -5.7
! 47.83 GHz  -6.5  -6.5
! 55.5 GHz  -7.2  -7.2
! 63.75 GHz  -8.0  -8.0
! 79.7 GHz  -9.3  -9.3
! 91.15 GHz  -10.3  -10.3
! 95.62 GHz  -10.7  -10.7
