! Created with skrf 1.10.0 (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS12 ImS12 ReS13 ImS13
! ReS14 ImS14
! ReS21 ImS21 ReS22 ImS22 ReS23 ImS23
! ReS24 ImS24
! ReS31 ImS31 ReS32 ImS32 ReS33 ImS33
! ReS34 ImS34
! ReS41 ImS41 ReS42 ImS42 ReS43 ImS43
! ReS44 ImS44
! Worked out from all points (differential pair):
!   400 points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, 75 MHz to 30 GHz, reference 50 ohm
!   strongest paths, dB at 75 MHz, 7.575 GHz, 15.07 GHz, 22.57 GHz, 30 GHz:
!     S43: -0.9, -8.7, -12.3, -15.0, -17.3
!     S21: -0.9, -8.7, -12.3, -15.0, -17.3
!     S42: -, -, -, -, -
!     S41: -, -, -, -, -
!     S32: -, -, -, -, -
!     S31: -, -, -, -, -
!   taken as a pair (ports 3,1 in; 4,2 out), SDD21 dB: -0.9, -8.7, -12.3, -15.0, -17.3
!   lowest |S11| = - dB at 75 MHz (marker M1), VSWR 1.00, Z = 50 + j0 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S43  S21
! 75 MHz  -0.9  -0.9
! 825 MHz  -2.9  -2.9
! 2.475 GHz  -5.0  -5.0
! 4.95 GHz  -7.0  -7.0
! 8.25 GHz  -9.1  -9.1
! 17.4 GHz  -13.2  -13.2
! 30 GHz  -17.3  -17.3
