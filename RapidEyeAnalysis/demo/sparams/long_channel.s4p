! Created with skrf 1.10.0 (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS12 ImS12 ReS13 ImS13
! ReS14 ImS14
! ReS21 ImS21 ReS22 ImS22 ReS23 ImS23
! ReS24 ImS24
! ReS31 ImS31 ReS32 ImS32 ReS33 ImS33
! ReS34 ImS34
! ReS41 ImS41 ReS42 ImS42 ReS43 ImS43
! ReS44 ImS44
! Worked out from all points (4-port):
!   1000 points, 50 MHz to 50 GHz, reference 50 ohm
!   strongest paths, dB at 50 MHz, 12.55 GHz, 25.05 GHz, 37.55 GHz, 50 GHz:
!     S43: -4.1, -64.2, -90.6, -110.9, -128.0
!     S21: -4.1, -64.2, -90.6, -110.9, -128.0
!     S41: -35.8, -72.6, -95.6, -113.8, -129.3
!     S32: -35.8, -72.6, -95.6, -113.8, -129.3
!     S42: -, -, -, -, -
!     S31: -, -, -, -, -
!   lowest |S11| = - dB at 50 MHz (marker M1), VSWR 1.00, Z = 50 - j1.99e-15 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S41  S32  S42  S31
! 50 MHz  -  -4.1  -4.1  -35.8  -35.8  -  -
! 1.2 GHz  -  -20.4  -20.4  -29.6  -29.6  -  -
! 5.8 GHz  -  -56.1  -56.1  -43.7  -43.7  -  -
! 11.8 GHz  -  -62.2  -62.2  -71.7  -71.7  -  -
! 16.75 GHz  -  -80.5  -80.5  -74.3  -74.3  -  -
! 19.6 GHz  -  -84.7  -84.7  -80.7  -80.7  -  -
! 50 GHz  -  -128.0  -128.0  -129.3  -129.3  -  -
